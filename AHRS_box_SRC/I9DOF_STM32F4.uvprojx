# Keil uVision project I9DOF_STM32F4.uvprojx, settings and files
target STM32F405_AHRS (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4_AHRS_BOX +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F40_41xxx,USE_USB_OTG_FS
  c include: .\Lib\inc;.\Lib\Include;.\User;.\HW_Driver\LED;.\HW_Driver\MS5611;.\HW_Driver\Service;.\HW_Driver\SPI2;.\HW_Driver\UART2;.\HW_Driver\USART_DMA;.\HW_Driver\IMU;.\HW_Driver\EEPROM;.\HW_Driver\ADC;.\FatFs;.\Lib\STM32_USB_Device_Library\Core\inc;.\Lib\STM32_USB_OTG_Driver\inc;.\Lib\STM32_USB_Device_Library\Class\msc\inc;.\HW_Driver\usbd_mass_storage;.\HW_Driver\SDIO;.\HW_Driver\BMI160;.\HW_Driver\QMC5883
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Lib
    ./Lib/src/: stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_flash.c stm32f4xx_adc.c stm32f4xx_sdio.c
    ./User/: startup_stm32f401xx.s
  group HW_Driver
    ./HW_Driver/LED/: LED.c
    ./HW_Driver/Service/: delay.c IOI2C.c SPI1.c Time3_Driver.c
    ./HW_Driver/MS5611/: MS5611.c
    ./HW_Driver/SPI2/: SPI2.c
    ./HW_Driver/EEPROM/: eeprom.c
    ./HW_Driver/IMU/: IMU.c
    ./HW_Driver/ADC/: STM32ADC.c
    ./HW_Driver/BMI160/: BMI160.c
    ./HW_Driver/QMC5883/: QMC5883.c
  group Source
    ./User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group FATFS
    ./FatFs/: FAT_driver.c diskio.c ff.c
    ./HW_Driver/SDIO/: sdio_sdcard.c
  group USB_OTG_Driver
    ./Lib/STM32_USB_OTG_Driver/src/: usb_dcd_int.c usb_core.c usb_dcd.c
  group USB_Device_Library
    ./Lib/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./Lib/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_MassStorage
    ./HW_Driver/usbd_mass_storage/: usb_bsp.c usb_it.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group USART
    ./HW_Driver/UART2/: UART2.c
    ./HW_Driver/USART_DMA/: OSQMem.c USART2DMATX.c UART1.c USART1DMATX.c
